FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://patch-esame.patch"